# IAR project USB_CDCACM.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ICCARM.CCDiagSuppress: Pe826
  ICCARM.CCIncludePath2: ..; $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  AARM.AUserIncludes: $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$
  OBJCOPY.OOCOutputFile: USB_CDCACM.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ICCARM.CCIncludePath2: $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$
  ICCARM.CCOptLevel: 3
  group (top)
    ../: main.c
  group CMSIS-Pack
    RTE/: RTE_Components.h
  group CMSIS-Pack/Peripherals GPIO
    ${CMSIS_PACK_PATH_Maxim#MAX32620#1.0.1}$/Libraries/MAX32620PeriphDriver/Source/: gpio.c ioman.c
  group CMSIS-Pack/MAXUSB MAXUSB
    ${CMSIS_PACK_PATH_Maxim#MAX32620#1.0.1}$/Libraries/MAXUSB/src/devclass/: cdc_acm.c fifo.c hid_kbd.c hid_raw.c
    ${CMSIS_PACK_PATH_Maxim#MAX32620#1.0.1}$/Libraries/MAXUSB/src/enumerate/: enumerate.c
    ${CMSIS_PACK_PATH_Maxim#MAX32620#1.0.1}$/Libraries/MAXUSB/src/core/arm/: usb.c
    ${CMSIS_PACK_PATH_Maxim#MAX32620#1.0.1}$/Libraries/MAXUSB/src/core/: usb_event.c
  group CMSIS-Pack/HAL Hardware Access Layer
    ${CMSIS_PACK_PATH_Maxim#MAX32620#1.0.1}$/Libraries/MAX32620PeriphDriver/Source/: clkman.c flc.c icc.c lp.c mxc_assert.c mxc_lock.c mxc_sys.c
    RTE/MAX32620/Maxim/: mxc_config.h
  group CMSIS-Pack/Device Startup
    RTE/MAX32620/Maxim/: cmain.s low_level_init.c max32620.h startup_max32620.s system_max32620.c
    ${CMSIS_PACK_PATH_Maxim#MAX32620#1.0.1}$/Libraries/MAX32620PeriphDriver/Source/: nvic_table.c
  group CMSIS-Pack/Communications UART
    ${CMSIS_PACK_PATH_Maxim#MAX32620#1.0.1}$/Libraries/MAX32620PeriphDriver/Source/: uart.c
  group CMSIS-Pack/Communications SPI Master
    ${CMSIS_PACK_PATH_Maxim#MAX32620#1.0.1}$/Libraries/MAX32620PeriphDriver/Source/: spim.c
  group CMSIS-Pack/Communications I2C Master
    ${CMSIS_PACK_PATH_Maxim#MAX32620#1.0.1}$/Libraries/MAX32620PeriphDriver/Source/: i2cm.c
  group CMSIS-Pack/CMSIS CORE
    ${CMSIS_PACK_PATH_ARM#CMSIS#5.2.0}$/CMSIS/Documentation/Core/html/: index.html
  group CMSIS-Pack/BSP Board Support
    ${CMSIS_PACK_PATH_Maxim#MAX32620#1.0.1}$/Boards/Maxim/MAX32620_EVKIT/Common/EvKit_V1/Source/: board.c
    ${CMSIS_PACK_PATH_Maxim#MAX32620#1.0.1}$/Boards/Maxim/MAX32620_EVKIT/Common/Source/: led.c max14690.c mx25.c nhd12832.c pb.c stdio.c
    ${CMSIS_PACK_PATH_Maxim#MAX32620#1.0.1}$/Documents/: MAX32620_EVKIT_Datasheet.pdf MAX32620_EVKIT_Schematic.pdf
