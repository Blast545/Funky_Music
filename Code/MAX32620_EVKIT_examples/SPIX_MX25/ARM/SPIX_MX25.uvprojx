# Keil uVision project SPIX_MX25.uvprojx, settings and files
target Flash Debug (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: MAX32620 Maxim
  pack: Maxim.MAX32620.0.0.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(96000000) ELITTLE
  output: SPIX_MX25
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --diag_suppress=1295,1296
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\SPIX_MX25.lin
  link misc: --keep=ramfunc.o(.xip_section)
  group Source
    ../: main.c ramfunc.c
    ./: Abstract.txt
software components: CMSIS:CORE 5.1.1, BSP:Board Support , Communications:I2C Master , Communications:SPI Master , Communications:SPI XIP , Communications:UART , Device:Startup , HAL:Hardware Access Layer , Peripherals:GPIO , Peripherals:Timers 
